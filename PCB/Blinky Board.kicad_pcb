# Repository ANSHUMANDOCX/Blinky-v1

File README.md:

# Blinky V1
A led chaser circuit using NE555 and CD4017 ICs which have a configurable speed using a 100K Ohm potentiometer

# Blinky - An LED chaser circuit using ICs only.
**The ICs used are:**
| Serial No.               | Part Name              | Purpose                 |
|:-------------------------|:----------------------:|:-----------------------:|
|1                         |NE555                  | Its the timer ic used to change the chase speeed.     |
|2                         |CD4017                  | It acts as a controller for controlling the LEDs.     |

Its a simple project made without any microcontrollers and just complete crude electronics 
It was a fun project to make learned quite a bit building the circuit.

## PCB and Schematic 

## Parts List:
These are the parts I used for making it:
| Serial No.               | Part Name              | Quantity                |
|:-------------------------|:----------------------:|:-----------------------:|
| 1                        | 100uF 25V Cap          | 1                       |
| 2                        | NE555P                 | 1                       |
| 3                        | CD4017BE               | 1                       |
| 4                        | 3296 Trim Pot 100k Ohm | 1                       |
| 5                        | 1k Ohm Resistor        | 1                       |
| 6                        | 470 Ohm Resistor       | 1                       |
| 7                        | 0.1uF Disc Cap         | 1                       |
| 8                        | Header Pin             | 2                       |
| 9                        | Through-Hole 5mm LED       | 10                      |

## KiCad design PCB/Blinky Board.kicad_pcb

Parts:
C1: 1uF; CP_Radial_D5.0mm_P2.00mm
C2: 0.01uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10: .; LED_D5.0mm_FlatTop
J1: Conn_01x02_Socket; PinHeader_1x02_P2.54mm_Vertical
J2: Conn_01x01_Pin; PinHeader_1x01_P2.54mm_Vertical
J3: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
R1: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1: 100K; Potentiometer_Bourns_3296W_Vertical
U1: NE555P; DIP-8_W7.62mm
U2: LM7805_TO220; TO-220-3_Vertical
U3: 4017; DIP-16_W7.62mm

Connections:
+5V: J1.1, R2.1, U1.4 (~RST), U1.8 (VCC), U2.3 (VO), U3.16 (VDD)
+9V: J3.1, U2.1 (VI)
/DIS: R2.2, RV1.1, RV1.2, U1.7 (DISCH)
/OUT: J2.1 (Pin_1_1), U1.3 (OUT), U3.14 (CLK)
/TR: C1.1, RV1.3, U1.2 (TRIG), U1.6 (THRES)
GND: C1.2, C2.1, J1.2, J3.2, R1.2, U1.1 (GND), U2.2 (GND), U3.8 (VSS), U3.13 (CKEN), U3.15 (Reset)
unnamed: D1.2 (A), U3.3 (Q0)
unnamed: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), R1.1
unnamed: D2.2 (A), U3.2 (Q1)
unnamed: D3.2 (A), U3.4 (Q2)
unnamed: D4.2 (A), U3.7 (Q3)
unnamed: D5.2 (A), U3.10 (Q4)
unnamed: D6.2 (A), U3.1 (Q5)
unnamed: D7.2 (A), U3.5 (Q6)
unnamed: D8.2 (A), U3.6 (Q7)
unnamed: D9.2 (A), U3.9 (Q8)
unnamed: D10.2 (A), U3.11 (Q9)
unnamed: C2.2, U1.5 (CONT)

Board: 2 copper layers, 70.0 x 70.0 mm, 21 parts (11 on the bottom side), 18 nets.
